FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-gdb-LoongArch-add-orig_a0-into-register-set.patch"

