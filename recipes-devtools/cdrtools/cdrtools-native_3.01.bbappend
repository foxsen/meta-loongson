FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://add-loongarch-rule.patch"
