FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://add-loongarch-triple.patch"

