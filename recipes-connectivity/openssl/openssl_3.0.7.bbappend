FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://loongarch-support.patch"
