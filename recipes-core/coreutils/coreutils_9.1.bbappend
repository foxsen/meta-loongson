FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-compilation-on-loongarch-__int128__-to-__int128.patch"

