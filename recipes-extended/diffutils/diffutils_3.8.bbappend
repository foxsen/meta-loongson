FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://diffutils-loongarch.patch"
